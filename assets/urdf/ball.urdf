Commit message: First commit

File: assets/urdf/ball.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: mass 0.5 -> 0.1; geometry collision sphere radius=0.02; visual sphere radius=0.02
